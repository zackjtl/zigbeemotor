<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TestRoutine.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TestRoutine</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>TestRoutine</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>TestRoutine</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


